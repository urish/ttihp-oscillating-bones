v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 340 100 340 120 {lab=VAPWR}
N 390 170 410 170 {lab=Y}
N 280 170 300 170 {lab=A}
C {devices/ipin.sym} 280 170 0 0 {name=p1 lab=A}
C {devices/opin.sym} 410 170 0 0 {name=p2 lab=Y}
C {devices/vdd.sym} 340 100 0 0 {name=l4 lab=VAPWR}
C {skullfet_inverter_5v_pwr.sym} 340 170 0 0 {name=x1}
